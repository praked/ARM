; PRANAV KEDIA - IMT2015518


  AREA appcode, CODE, READONLY
		export __main
		
		ENTRY
__main  function
		MOV R1,#8 ;x
		MOV R2, #9 ;Y
		LDR R5, =0x20000001
		MOV R3, #320 ; 
		MOV R4, #240 ;	
		MOV R6, #0 ;
		MOV R7, #0 ; 
AGNX 	CMP R6, R4 ;
		BHI INI
		STRB R1,[R5,R7]
		ADD  R7,R7,#1
		STRB R6,[R5,R7]
		ADD  R6,R6,#1
		ADD  R7,R7,#1
		B    AGNX
INI		MOV R6,#0;
		B AGNY
AGNY	CMP R6,R3;
		BHI DRAWCROSSWIRE
		STRB R6,[R5,R7]
		ADD  R6,R6,#1
		ADD  R7,R7,#1
		STRB R2,[R5,R7]
		ADD  R7,R7,#1
		B    AGNY
DRAWCROSSWIRE	B STOP	; CAN USE R5 TO ACCESS THE BASE ADDRESS TO COORDINATES 
						; ARRAY OF CROSS WIRE	
STOP    B STOP ; stop program
     ENDFUNC
	 END		