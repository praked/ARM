; PRANAV KEDIA - IMT2015518

  AREA appcode, CODE, READONLY
		export __main
		
		ENTRY
__main  function
		LDR R2,=0X20000001;
		MOV R1,#5;   MAX X
		MOV R8,#4;	 MAX Y	
		MOV R4,#0;   TOTAL ELEMENTS
		MOV R5,#0;	  ITERATOR
		MOV R6,#2;    INITIAL KEY 
		MUL R4,R8,R1; MULTIPLICATION
ENCP 	CMP R5, R4 ;
		BEQ INI
		LDRB R7,[R2,R5]
		MOV R9,R7;
		EOR R7,R6,R7;  XOR OPERATION
		MOV R6, R9
		STRB R7,[R2,R5]
		ADD  R5,R5,#1
		B    ENCP
INI 	MOV R3,R2
		B SENDDATATONETWORK
SENDDATATONETWORK	B STOP ; CAN USE R1 ADDR TO ACCESS THE BASE ADDRESS TO IMAGE 
						   ; ARRAY OF CROSS WIRE		
STOP    B STOP ; stop program
     ENDFUNC
	 END		